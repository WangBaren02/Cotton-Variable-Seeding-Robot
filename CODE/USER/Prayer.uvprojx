# Keil uVision project Prayer.uvprojx, settings and files
target Prayer (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Prayer +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,__TARGET_FPU_VFP=1
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\sys;..\HARDWARE\LED;..\SYSTEM\delay;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\USART1_DMA;..\HARDWARE\USART2_DMA;..\HARDWARE\USART3_DMA;..\HARDWARE\UART4_DMA;..\HARDWARE\TIMER7;..\SYSTEM\CONTROL;..\HARDWARE\SERVO;..\HARDWARE\ULTRASONIC;..\HARDWARE\PARAM;..\HARDWARE\MOTOR;..\HARDWARE\ENCODER;..\DMP\driver\eMPL;..\DMP\driver\include;..\DMP\driver\stm32L;..\DMP\eMPL-hal;..\DMP\mllite;..\DMP\mpl;..\SYSTEM\PID;..\HARDWARE\TFLUNA;..\SYSTEM\PID;..\HARDWARE\FILTER;..\HARDWARE\IO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../SYSTEM/CONTROL/: control.c
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/PID/: pid.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/USART1_DMA/: usart1_dma.c
    ../HARDWARE/USART2_DMA/: usart2_dma.c
    ../HARDWARE/USART3_DMA/: usart3_dma.c
    ../HARDWARE/UART4_DMA/: uart4_dma.c
    ../HARDWARE/TIMER7/: timer7.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/ULTRASONIC/: ultrasonic.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/TFLUNA/: TFLuna.c
    ../HARDWARE/FILTER/: filter.c
    ../HARDWARE/IO/: io.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
